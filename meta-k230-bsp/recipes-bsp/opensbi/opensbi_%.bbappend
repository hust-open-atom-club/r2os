FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-lib-sbi-skip-unusable-single-entry-pmp-protection.patch"
